<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>burst_app</value></param>
<param><key>author</key><value>Tim O'Shea</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>pre_hook</key><value>None</value></param>
<param><key>post_hook</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e5</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>/tmp/mod.out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_skiphead</key>
<param><key>id</key><value>gr_skiphead_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>500</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channel_model_0</value></param>
<param><key>noise_voltage</key><value>1e-2</value></param>
<param><key>freq_offset</key><value>random.random()*1e-2</value></param>
<param><key>epsilon</key><value>1 + random.random()*1e-2</value></param>
<param><key>taps</key><value>[1+1.0j]</value></param>
<param><key>seed</key><value>42</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_1</value></param>
<param><key>file</key><value>/tmp/detect_stat.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>burst_tx</key>
<param><key>id</key><value>burst_tx_0</value></param>
<param><key>pool_size</key><value>1</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>arb</key><value>variable_es_arb_0</value></param>
<param><key>queue</key><value>variable_tx_queue</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>iir_filter_ffd</key>
<param><key>id</key><value>iir_filter_ffd_0</value></param>
<param><key>fftaps</key><value>0.1</value></param>
<param><key>fbtaps</key><value>0.9</value></param>
<param><key>oldstyle</key><value>True</value></param>
</block>
<block>
<key>variable_es_queue</key>
<param><key>id</key><value>variable_rx_queue</value></param>
<param><key>value</key><value>QUEUE OK</value></param>
<param><key>eb</key><value>balk</value></param>
</block>
<block>
<key>variable_es_arb</key>
<param><key>id</key><value>variable_es_arb_0</value></param>
<param><key>value</key><value>ARB OK</value></param>
<param><key>hash</key><value>{'someval1':1, 'someval2':2}</value></param>
</block>
<block>
<key>burst_rx</key>
<param><key>id</key><value>burst_rx_0</value></param>
<param><key>pool_size</key><value>1</value></param>
</block>
<block>
<key>es_trigger_sample_timer</key>
<param><key>id</key><value>es_trigger_sample_timer_0</value></param>
<param><key>queue</key><value>variable_tx_queue</value></param>
<param><key>length</key><value>50000</value></param>
<param><key>period</key><value>int(1e5)</value></param>
<param><key>shift</key><value>int(200e3)</value></param>
<param><key>sched_dist</key><value>int(4e6)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>variable_es_queue</key>
<param><key>id</key><value>variable_tx_queue</value></param>
<param><key>value</key><value>QUEUE OK</value></param>
<param><key>eb</key><value>balk</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>evtype</key><value>trigger_1</value></param>
<param><key>arb</key><value>variable_es_arb_0</value></param>
<param><key>queue</key><value>variable_rx_queue</value></param>
<param><key>thresh</key><value>5</value></param>
<param><key>length</key><value>25000</value></param>
<param><key>lookback</key><value>5000</value></param>
<param><key>guard</key><value>10000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_nlog10_ff</key>
<param><key>id</key><value>gr_nlog10_ff_0</value></param>
<param><key>n</key><value>1</value></param>
<param><key>k</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>gr_delay</key>
<param><key>id</key><value>gr_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>2000</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_divide_xx</key>
<param><key>id</key><value>gr_divide_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>arb</key><value>variable_es_arb_0</value></param>
<param><key>queue</key><value>variable_rx_queue</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>nthreads</key><value>1</value></param>
</block>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_model_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_model_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_divide_xx_0_0</source_block_id><sink_block_id>iir_filter_ffd_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_ffd_0</source_block_id><sink_block_id>gr_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_nlog10_ff_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_model_0</source_block_id><sink_block_id>gr_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>es_trigger_sample_timer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_delay_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_model_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_nlog10_ff_0</source_block_id><sink_block_id>gr_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_skiphead_0</source_block_id><sink_block_id>gr_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>gr_divide_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>gr_divide_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_delay_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

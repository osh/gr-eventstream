<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>morse_letter_handler</value></param>
<param><key>title</key><value>Morse Letter Handler</value></param>
<param><key>author</key><value>Tim O'Shea</value></param>
<param><key>generate_options</key><value>evt</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>pre_hook</key><value>pre_hook</value></param>
<param><key>post_hook</key><value>post_hook</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44.1e3</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>head</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_es_post_hook</key>
<param><key>id</key><value>post_hook</value></param>
<param><key>value</key><value>""
blocks = val.handler.pb2();
blocks['head'].reset();
 ""</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>500</value></param>
<param><key>amp</key><value>0.9</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pool_size</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>variable_es_pre_hook</key>
<param><key>id</key><value>pre_hook</value></param>
<param><key>value</key><value>""# get blocks reference
blocks = val.handler.pb2();

# grab the key argument if it exists.
key = "a";
keypmt = pmt.pmt_intern("key");
if(es.event_has_field(val.msg,keypmt)):
    keyarg = es.event_field( val.msg, keypmt);
    key = pmt.pmt_symbol_to_string( keyarg );
  
# define look up table  
code = {
'a': [0,1],  'b': [1,0,0],  'c':[1,0,1,0], 'd':[1,0,0], 'e':[0], 'f':[0,0,1,0], 'g':[1,1,0], 'h':[0,0,0,0], 
'i': [0,0], 'j':[0,1,1,1], 'k':[1,0,1], 'l':[0,1,0,0], 'm':[1,1], 'n':[1,0], 'o':[1,1,1], 'p':[0,1,1,0], 
'q':[1,1,0,1], 'r':[0,1,0], 's':[0,0,0], 't':[1], 'u':[0,0,1], 'v':[0,0,0,1], 'w':[0,1,1], 'x':[1,0,0,1],
'y':[1,0,1,1], 'z':[1,1,0,0]
};

mc = [];
try:
   mc = code[key.lower()];
   print mc;
except:
   pass

samp_rate = 44100;
#dot_len = int(samp_rate * (60.0e-3));
dot_len = int(samp_rate * (120.0e-3));
dash_len = int(3*dot_len);

nvs = []; 
for v in mc:
   lvals = [dot_len, dash_len];

   # on for dot or dash len
#   nvs.extend( lvals[v]*[1] );
   nvs.extend( numpy.ones(lvals[v]) );

   # off for dot len
#   nvs.extend( dot_len*[0] );
   nvs.extend( numpy.zeros(dot_len) );

# space letters by dash-len off period
#nvs.extend( dash_len*[0] );
nvs.extend( numpy.zeros(dash_len) );

blocks['vec_src'].set_data(nvs);
#print nvs;

#print "set length - %d"%(len(nvs));
blocks['head'].set_length( len(nvs) );
blocks['head'].reset();

   ""</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>vec_src</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>[]</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>head</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>head</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vec_src</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>

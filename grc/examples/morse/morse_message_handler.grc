<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>morse_message_handler</value></param>
<param><key>title</key><value>Morse Message Handler</value></param>
<param><key>author</key><value>Tim O'Shea</value></param>
<param><key>generate_options</key><value>evt</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>pre_hook</key><value>pre_hook</value></param>
<param><key>post_hook</key><value>post_hook</value></param>
</block>
<block>
<key>variable_es_post_hook</key>
<param><key>id</key><value>post_hook</value></param>
<param><key>value</key><value>""print "post hook" ""</value></param>
</block>
<block>
<key>variable_es_arb</key>
<param><key>id</key><value>a0</value></param>
<param><key>value</key><value>ARB OK</value></param>
<param><key>hash</key><value>{}</value></param>
</block>
<block>
<key>variable_es_queue</key>
<param><key>id</key><value>q0</value></param>
<param><key>value</key><value>QUEUE OK</value></param>
<param><key>eb</key><value>balk</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>44.1e3</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>arb</key><value>a0</value></param>
<param><key>queue</key><value>q0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>morse_letter_handler</key>
<param><key>id</key><value>morse_letter_handler_0</value></param>
<param><key>samp_rate</key><value>44.1e3</value></param>
<param><key>pool_size</key><value>1</value></param>
</block>
<block>
<key>variable_es_pre_hook</key>
<param><key>id</key><value>pre_hook</value></param>
<param><key>value</key><value>""print "pre hook" ""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pool_size</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

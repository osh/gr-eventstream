<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable_es_pre_hook</key>
<param><key>id</key><value>variable_es_pre_hook_0</value></param>
<param><key>value</key><value>""#grab reference to blocks dict
blocks = val.handler.pb2();

#default to busy tone
f1 = 480;
f2 = 620;

# grab the key argument if it exists.
keypmt = pmt.pmt_intern("key");
if(es.event_has_field(val.msg,keypmt)):
    keyarg = es.event_field( val.msg, keypmt);
    key = pmt.pmt_symbol_to_string( keyarg );
    
    # remap *,# and 0 keys for DTMF
    if(key == "*"):
        key = "10";
    elif(key == "#"):
        key = "12";
    elif(key=="0"):
        ival = 11;
    
    # if key is numeric set corresponding DTMF grid frequencies
    try:
        ival = int(key);
        row = (ival - 1)/3;
        col = (ival - 1)%3;
        rowfreqs = [697.0, 770.0, 852.0, 941.0];
        colfreqs = [1209.0, 1336.0, 1477.0, 1633.0];
        f1 = rowfreqs[row];
        f2 = colfreqs[col];
    
    except:
        print "ignoring non-numeric key"
        pass

# set block frequencies before running
blocks["gr_sig_source_x_0"].set_frequency(f1);
blocks["gr_sig_source_x_1"].set_frequency(f2);                
     ""</value></param>
</block>
<block>
<key>variable_es_post_hook</key>
<param><key>id</key><value>variable_es_post_hook_0</value></param>
<param><key>value</key><value>""# grab reference to blocks dict
blocks = val.handler.pb2();

# reset the head blocks when done with them
blocks['gr_head_0'].reset();
blocks['gr_head_1'].reset();  
 ""</value></param>
</block>
<block>
<key>variable_es_evt</key>
<param><key>id</key><value>freq1</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>330.0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>req</key><value>True</value></param>
</block>
<block>
<key>variable_es_evt</key>
<param><key>id</key><value>freq2</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>440.0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>req</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>scale</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>value</key><value>variable_es_pre_hook_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pool_size</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>5000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>5000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>freq2</value></param>
<param><key>amp</key><value>scale</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>freq1</value></param>
<param><key>amp</key><value>scale</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>sin_event</value></param>
<param><key>title</key><value>Dual-Sin Synth Handler</value></param>
<param><key>author</key><value>Tim O'Shea</value></param>
<param><key>generate_options</key><value>evt</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>pre_hook</key><value>variable_es_pre_hook_0</value></param>
<param><key>post_hook</key><value>variable_es_post_hook_0</value></param>
</block>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_head_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_1</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

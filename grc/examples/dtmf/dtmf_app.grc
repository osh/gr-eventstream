<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dtmf_app</value></param>
<param><key>title</key><value>DTMF Keypad</value></param>
<param><key>author</key><value>Tim O'Shea</value></param>
<param><key>description</key><value>Eventstream DTMF Example App</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>pre_hook</key><value>None</value></param>
<param><key>post_hook</key><value>None</value></param>
</block>
<block>
<key>variable_es_arb</key>
<param><key>id</key><value>variable_es_arb_0</value></param>
<param><key>value</key><value>ARB OK</value></param>
<param><key>hash</key><value>{'someval':1, 'someval2':2}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>event_length</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Enable Timers for Fun</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>System-Timer has Jitter</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>Sample-Timer should not</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>es_keyboard_trigger</key>
<param><key>id</key><value>es_keyboard_trigger_0</value></param>
<param><key>queue</key><value>variable_es_queue_0</value></param>
<param><key>length</key><value>event_length</value></param>
</block>
<block>
<key>es_source2</key>
<param><key>id</key><value>es_source2_0</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>arb</key><value>variable_es_arb_0</value></param>
<param><key>queue</key><value>variable_es_queue_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>2</value></param>
</block>
<block>
<key>sin_event</key>
<param><key>id</key><value>sin_event_0</value></param>
<param><key>scale</key><value>0.9</value></param>
<param><key>pool_size</key><value>1</value></param>
</block>
<block>
<key>variable_es_queue</key>
<param><key>id</key><value>variable_es_queue_0</value></param>
<param><key>value</key><value>QUEUE OK</value></param>
<param><key>eb</key><value>asap</value></param>
</block>
<block>
<key>es_trigger_sample_timer</key>
<param><key>id</key><value>es_trigger_sample_timer_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>queue</key><value>variable_es_queue_0</value></param>
<param><key>length</key><value>event_length</value></param>
<param><key>period</key><value>10000</value></param>
<param><key>shift</key><value>5000</value></param>
<param><key>sched_dist</key><value>25000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>es_timer_trigger</key>
<param><key>id</key><value>es_timer_trigger_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>queue</key><value>variable_es_queue_0</value></param>
<param><key>length</key><value>5000</value></param>
<param><key>delay</key><value>1.0</value></param>
<param><key>iterations</key><value>-1</value></param>
</block>
<connection><source_block_id>es_source2_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>es_source2_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source2_0</source_block_id><sink_block_id>es_trigger_sample_timer_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
